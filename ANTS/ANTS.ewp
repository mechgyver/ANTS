# IAR project ANTS.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1313 NXP LPC1313
  ICCARM.CCIncludePath2: $PROJ_DIR$; cc_libs; ANTS_Common_IAR\inc; ANTS_Common_IAR\src; ads_libs
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: ANTS_Common_IAR\src
  OBJCOPY.OOCOutputFile: ANTS.srec
  ILINK.IlinkOutputFile: ANTS.out
  ILINK.IlinkIcfFile: icf\LPC1343_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group ads_libs
    ads_libs/: ads1115.c ads1115.h
  group cc_libs
    cc_libs/: CC2500.c CC2500.h CC_CC2500.h CC_spi.c CC_spi.h
  group Common
    ANTS_common_IAR/inc/: arm_comm.h board.h gpio.h i2c.h LPC13xx.h ssp.h systick.h timer16.h timer32.h
    ANTS_common_IAR/src/: clkconfig.c core_cm3.c cstartup_M.s gpio.c i2c.c pmu.c ssp.c system_LPC13xx.c timer16.c timer32.c uart.c
    ANTS_Common_IAR/inc/: clkconfig.h core_cm3.h pmu.h stdint.h system_LPC13xx.h type.h uart.h
